/**
  ******************************************************************************
  * @file    drv_dbus.c
  * @brief   大疆 DBUS 协议：把 18 个字节拆成摇杆数值
  *
  *  本文件一共 3 个函数，都在 drv_dbus.h 里写了"在哪被调用"。
  *  这里只讲"怎么实现的"。
  *
  *  ★ 为了让你看得懂，本文件刻意不用任何花哨写法：
  *    - 不用三目运算符 ? :
  *    - 不写复杂的类型强转
  *    - 一个语句只做一件事
  *    - 每个数字都告诉你是哪来的
  ******************************************************************************
  */
#include "drv_dbus.h"

/**
  * @brief  取出第 ch 个摇杆通道的值（11 位）
  * @note   调用位置：task_chassis.c 的 Task_Chassis_Loop()，1kHz
  * @note   实现位置：就是下面这个函数
  * @param  rc  遥控器数据（一般传 &rc_data）
  * @param  ch  通道号 0~3
  * @retval 0 ~ 2047
  */
uint16_t DBUS_GetChannel(const RC_Ctl_Define_t *rc, uint8_t ch)
{
    uint16_t value;

    /* ------------------------------------------------------------------------
     *  ch0：占 byte0 的全部 8 位 + byte1 的低 3 位，一共 11 位
     * ------------------------------------------------------------------------
     *  buf[1] << 8   : 把 byte1 整体往左挪 8 位，让它站到"高 8 位"的位置
     *  | buf[0]      : 把 byte0 放到低 8 位（按位或，就是拼在一起）
     *  & 0x07FF      : 只保留低 11 位，多余的切掉
     *                  （0x07FF = 二进制 0000 0111 1111 1111，正好 11 个 1）
     * --------------------------------------------------------------------- */
    if (ch == 0) {
        value = rc->buf[0] | (rc->buf[1] << 8);
        return value & 0x07FF;
    }

    /* ------------------------------------------------------------------------
     *  ch1：byte1 的高 5 位 + byte2 的全部 8 位
     * ------------------------------------------------------------------------
     *  buf[1] >> 3   : 把 byte1 右移 3 位，把上面那 3 位（ch0 的）扔掉，
     *                  剩下的就是 ch1 的低 5 位
     *  buf[2] << 5   : byte2 左移 5 位，接到上面那 5 位后面
     *  & 0x07FF      : 只留 11 位
     * --------------------------------------------------------------------- */
    if (ch == 1) {
        value = (rc->buf[1] >> 3) | (rc->buf[2] << 5);
        return value & 0x07FF;
    }

    /* ------------------------------------------------------------------------
     *  ch2：byte2 的高 2 位 + byte3 的全部 8 位 + byte4 的最低位
     * ------------------------------------------------------------------------
     *  buf[2] >> 6   : 右移 6 位，只剩下最高那 2 位
     *  buf[3] << 2   : byte3 左移 2 位，接到那 2 位后面
     *  buf[4] << 10  : byte4 左移 10 位。左移 10 位之后，
     *                  整个数只有最低位还落在 11 位之内（其余位会被掩码切掉），
     *                  所以等价于只取 byte4 的最低位
     *  & 0x07FF      : 只留 11 位
     *
     *  ★ 三行看着唬人，其实就是"三个字节里各取一段，拼成一个 11 位数"。
     *    你原来代码里就是这么写的，完全正确，我只是把它拆成一行一行。
     * --------------------------------------------------------------------- */
    if (ch == 2) {
        value = (rc->buf[2] >> 6) | (rc->buf[3] << 2) | (rc->buf[4] << 10);
        return value & 0x07FF;
    }

    /* ------------------------------------------------------------------------
     *  ch3：byte4 的高 7 位 + byte5 的低 4 位
     * ------------------------------------------------------------------------
     *  buf[4] >> 1   : 右移 1 位，扔掉最低位（那是 ch2 的），剩 7 位
     *  buf[5] << 7   : byte5 左移 7 位接到后面（左移 7 位后只剩低 4 位有效，
     *                  其余会被掩码切掉）
     *  & 0x07FF      : 只留 11 位
     * --------------------------------------------------------------------- */
    if (ch == 3) {
        value = (rc->buf[4] >> 1) | (rc->buf[5] << 7);
        return value & 0x07FF;
    }

    /* 只有 0~3 四个通道，传别的数字就是写错了，返回 0 */
    return 0;
}

/**
  * @brief  取拨杆 S1 / S2
  * @note   调用位置：目前没被调用，留给你以后切模式用
  * @note   实现位置：就是下面这个函数
  * @param  rc     遥控器数据
  * @param  which  1 = 取 S1，其它 = 取 S2
  * @retval 1 / 2 / 3
  */
uint8_t DBUS_GetSwitch(const RC_Ctl_Define_t *rc, uint8_t which)
{
    uint8_t value;

    /* S1 和 S2 都住在 byte5 里，各占 2 位：
         byte5 的 bit4~5 -> S1
         byte5 的 bit6~7 -> S2
       0x03 = 二进制 11，用来只保留最低 2 位。 */
    if (which == 1) {
        value = rc->buf[5] >> 4;     /* 右移 4 位，把 S1 挪到最低 2 位 */
        return value & 0x03;         /* 只留 2 位 */
    }

    value = rc->buf[5] >> 6;         /* 右移 6 位，把 S2 挪到最低 2 位 */
    return value & 0x03;
}

/**
  * @brief  把遥控器数据改成"摇杆全部回中"的安全值
  * @note   调用位置：task_rc.c 的 Task_RC_Loop()，判断出关控时调用
  * @note   实现位置：就是下面这个函数
  * @param  rc  要改的遥控器数据（一般传 &rc_data）
  * @retval 无
  *
  * ==========================================================================
  *  这 6 个字节是怎么算出来的？（跟着看一遍就懂了）
  * ==========================================================================
  *  目标：让 4 个通道都等于中位 1024，2 个拨杆都等于 2（中位）。
  *
  *  1024 写成二进制是：
  *      1024 = 0x400 = 二进制 100_0000_0000
  *      也就是"11 位里的第 10 位是 1，其余全是 0"
  *
  *  所以 ch2 的高 1 位（在 byte4 的最低位）必须是 1，其余通道都靠别的字节，
  *  一个字节一个字节倒推，就得到下面这 6 个数值。
  *
  *  验算（用上面 DBUS_GetChannel 的公式算一遍）：
  *
  *     ch0 = buf[0] | (buf[1]<<8)          = 0x00 | 0x0400 = 0x400 = 1024 ✓
  *     ch1 = (buf[1]>>3) | (buf[2]<<5)     = 0    | 0x0400 = 0x400 = 1024 ✓
  *     ch2 = (buf[2]>>6) | (buf[3]<<2) | (buf[4]<<10)
  *                                          = 0 | 0 | 0x0400 = 1024 ✓
  *     ch3 = (buf[4]>>1) | (buf[5]<<7)     = 0    | 0x0400 = 0x400 = 1024 ✓
  *     s1  = (buf[5]>>4) & 0x03            = 0x0A & 3 = 2 ✓
  *     s2  = (buf[5]>>6) & 0x03            = 0x02 & 3 = 2 ✓
  *
  *  全部正确。
  * ========================================================================== */
void DBUS_SetSafeValue(RC_Ctl_Define_t *rc)
{
    uint8_t i;

    /* 前 6 个字节是摇杆和拨杆，按上面算出来的值填 */
    rc->buf[0] = 0x00;   /* ch0 的低 8 位 = 0 */
    rc->buf[1] = 0x04;   /* ch0 的高 3 位 = 4（即二进制 100），同时 ch1 的低 5 位 = 0 */
    rc->buf[2] = 0x20;   /* ch1 的高 6 位 = 32（0x20），同时 ch2 的低 2 位 = 0 */
    rc->buf[3] = 0x00;   /* ch2 的中间 8 位 = 0 */
    rc->buf[4] = 0x01;   /* ch2 的最高 1 位 = 1，同时 ch3 的低 7 位 = 0 */
    rc->buf[5] = 0xA8;   /* ch3 的高 4 位 = 8，s1 = 2，s2 = 2 */

    /* 后面 12 个字节（鼠标、键盘、保留位）全部清 0 */
    for (i = 6; i < DBUS_LEN; i++) {
        rc->buf[i] = 0x00;
    }
}
