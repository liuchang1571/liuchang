/**
  ******************************************************************************
  * @file    ackermann.c
  * @brief   齿条式阿卡曼 逆运动学 实现
  *
  *  ============================================================================
  *  一句话总结这个函数做的事：
  * ============================================================================
  *      "车想往前开 base_rpm 那么快、齿条想停在 rack_mm 这个位置，
  *       那左右两个后轮各应该转多少 rpm？"
  *
  *  分 7 步算：
  *      第 1 步：齿条位置限幅（不能超出 ±22mm）
  *      第 2 步：齿条毫米数 -> 等效前轮转角 δ（度）
  *      第 3 步：直行判断（δ 几乎是 0 的时候不用差速）
  *      第 4 步：前轮转角 -> 转弯半径 R
  *      第 5 步：算"理想阿卡曼"的两个前轮转角（只用来对比，不发电机）
  *      第 6 步：用 R 算出左右后轮的差速比例
  *      第 7 步：转速限幅（不能超过电机能力）
  *
  *  ★ 本文件刻意用最基础的写法：
  *    每个变量先声明再赋值，一个语句只做一件事，
  *    所有数字都标出来源。
  ******************************************************************************
  */
#include "ackermann.h"
#include "config.h"
#include <math.h>      /* tanf / atanf 三角函数，fabsf 求浮点绝对值 */

/* 圆周率。写常量比用 M_PI 更保险（有些编译环境不定义 M_PI） */
#define PI_F  3.14159265f

/**
  * @brief  齿条式阿卡曼逆运动学解算
  * @note   调用位置：task_chassis.c 的 Task_Chassis_Loop() 第 ③ 步，1kHz
  * @note   实现位置：就是下面这个函数
  * @param  base_rpm  摇杆给的速度，单位【转子 rpm】
  * @param  rack_mm   摇杆给的转向，单位【毫米】，正 = 向左
  * @param  out       解算结果
  * @retval  无
  */
void Ackermann_Solve(float base_rpm, float rack_mm, Ackermann_Out_t *out)
{
    /* ---- 先声明本函数要用到的所有变量（C 语言习惯，方便阅读）---- */
    float delta_deg;      /* 等效前轮转角，单位：度 */
    float delta_use;      /* 拿来算半径的转角（做过保护），单位：度 */
    float delta_rad;      /* 转成弧度，因为 tan 要弧度 */
    float radius;         /* 转弯半径 R，单位：毫米（带正负：正=左转） */
    float radius_abs;     /* 转弯半径的绝对值，单位：毫米 */
    float half_rear;      /* 半个【后】轮距 = 332/2 = 166mm */
    float half_front;     /* 半个【前】轮距 = 342/2 = 171mm */
    float ratio_left;     /* 左后轮的速度比例 */
    float ratio_right;    /* 右后轮的速度比例 */
    float inner_deg;      /* 内前轮转角（绝对大小），度 */
    float outer_deg;      /* 外前轮转角（绝对大小），度 */
    float rpm_max;        /* 左右两个目标里，绝对值大的那个 */
    float scale;          /* 限幅时用的缩放系数 */

    /* ======================================================================
     *  第 1 步：齿条位置限幅
     * ----------------------------------------------------------------------
     *  齿条从中心到两侧各有 46mm 的物理行程，软件限位设在 ±45mm。
     *  不管传进来什么值（哪怕解算写错、传了 999），
     *  这里先压到 ±45mm 之内。
     *
     *  ★ 为什么一定要限？
     *    因为齿条走到头就是一块铁顶着一块铁，
     *    再让它往前走，电机就堵转，电流一直拉满，很快就烧。
     * ==================================================================== */
    if (rack_mm > STEER_RACK_MM_MAX)
    {
        rack_mm = STEER_RACK_MM_MAX;
    }
    if (rack_mm < -STEER_RACK_MM_MAX)
    {
        rack_mm = -STEER_RACK_MM_MAX;
    }

    /* 把限幅后的齿条位置传给上层（steer 模块还会再限一次，双保险） */
    out->rack_mm = rack_mm;

    /* ======================================================================
     *  第 2 步：齿条毫米数 -> 等效前轮转角 δ
     * ----------------------------------------------------------------------
     *  用【线性近似】：
     *
     *      δ = 齿条位置 / 45mm × 满行程时的转角（STEER_MAX_DEG）
     *
     *  举例（STEER_MAX_DEG = 28）：
     *      齿条 0mm    -> δ = 0 度（直行）
     *      齿条 22.5mm -> δ = 14 度
     *      齿条 45mm   -> δ = 28 度（打满）
     *
     *  ★ 严格来说齿条和转角是 tan 关系（非线性），
     *    但线性近似在中小角度误差很小，对后轮差速来说完全够用。
     * ==================================================================== */
    delta_deg = rack_mm / STEER_RACK_MM_MAX * STEER_MAX_DEG;

    /* 存下来给调试看（调试器里能看到前轮大概转了多少度） */
    out->delta_deg = delta_deg;

    /* ======================================================================
     *  第 3 步：直行判断
     * ----------------------------------------------------------------------
     *  当前轮几乎不转（|δ| < 0.5 度）的时候，就当直行处理：
     *  左右后轮转速一模一样，两个前轮也都是 0 度。
     *
     *  ★ 为什么必须先判断？
     *    因为下一步要算 tan(δ)，
     *    δ = 0 时 tan(0) = 0，半径 R = 296.33/0 会变成无穷大，
     *    计算机会得到一个"NaN"（不是数字），
     *    后面所有计算全部变成垃圾，车会发疯。
     *    这是所有除零问题里最经典的一个，必须挡住。
     * ==================================================================== */
    if (delta_deg > -0.5f && delta_deg < 0.5f)
    {
        out->rear_rpm[0]  = base_rpm;     /* 左后轮 */
        out->rear_rpm[1]  = base_rpm;     /* 右后轮 */
        out->front_deg[0] = 0.0f;         /* 左前轮 */
        out->front_deg[1] = 0.0f;         /* 右前轮 */
        return;                           /* 直行，不需要差速，直接返回 */
    }

    /* ======================================================================
     *  第 4 步：前轮转角 -> 转弯半径 R
     * ----------------------------------------------------------------------
     *  自行车模型：
     *
     *      R = 轴距 / tan(δ)
     *
     *  举例（轴距 296.33mm）：
     *      δ = 28 度 -> tan = 0.5317 -> R = 296.33/0.5317 = 557 mm
     *      δ = 14 度 -> tan = 0.2493 -> R = 296.33/0.2493 = 1189 mm
     *
     *  ★ 正负号的含义：
     *      δ > 0（向左转）-> R > 0
     *      δ < 0（向右转）-> R < 0
     *    后面的差速公式对正负号是自洽的，不用特殊处理右转。
     * ==================================================================== */

    /* ---- 先做一个保护：把算半径用的转角压在 ±50 度以内 ----
     * 为什么？
     *   如果 STEER_MAX_DEG 被误填成 80 度，
     *   tan(80) = 5.67，R = 296/5.67 = 52mm，
     *   比半个后轮距 166mm 还小，
     *   差速比例会算出负数（意味着车轮要倒转），这不合理。
     *   压到 50 度之后，最小 R = 296.33/tan(50) = 248mm，
     *   永远大于 166mm，绝不会出问题。 */
    delta_use = delta_deg;
    if (delta_use > 50.0f)
    {
        delta_use = 50.0f;
    }
    if (delta_use < -50.0f)
    {
        delta_use = -50.0f;
    }

    /* 角度转弧度。tan 函数要的是弧度，不是角度。
     * 弧度 = 角度 × π / 180 */
    delta_rad = delta_use * PI_F / 180.0f;

    /* 算转弯半径（还没取绝对值，保留正负号） */
    radius = WHEEL_BASE_MM / tanf(delta_rad);

    /* ======================================================================
     *  第 5 步：算"理想阿卡曼"的两个前轮转角 ★只用来对比，不发给电机★
     * ----------------------------------------------------------------------
     *  真正的阿卡曼要求：
     *      内前轮转角 > 外前轮转角，而且满足
     *          cot(内) - cot(外) = 前轮距 / 轴距
     *
     *  公式（Wf 是前轮距 342mm）：
     *      内前轮 = atan( 轴距 / (|R| - Wf/2) )
     *      外前轮 = atan( 轴距 / (|R| + Wf/2) )
     *
     *  为什么用 |R|？
     *    R 的符号只表示"左转还是右转"，
     *    内外轮的角度大小只跟半径的"大小"有关。
     *
     *  验算（左打满，δ = 28°，前轮距 342，轴距 296.33）：
     *      R = 296.33 / tan(28°) = 557.3mm
     *      内轮 = atan(296.33 / (557.3 - 171)) = atan(0.767) = 37.5°
     *      外轮 = atan(296.33 / (557.3 + 171)) = atan(0.407) = 22.1°
     *      验算阿卡曼条件：
     *          cot(37.5°) - cot(22.1°) = 1.303 - 2.458 = -1.155
     *          前轮距/轴距 = 342/296.33 = 1.154
     *      绝对值一致 ✓ 说明公式是对的
     *
     *  ★ 这两个角度算出来只是给你量车用的：
     *    拿量角器去量实车左右前轮，
     *    看看你的梯形拉杆有没有做到"内轮多、外轮少"。
     *    做得不好不影响这套代码（因为程序控制的是齿条），
     *    但会影响轮胎寿命和转弯阻力。
     * ==================================================================== */
    half_front = WHEEL_TRACK_FRONT_MM / 2.0f;     /* 342 / 2 = 171mm */
    radius_abs = fabsf(radius);

    if (radius_abs > half_front)
    {
        inner_deg = atanf(WHEEL_BASE_MM / (radius_abs - half_front)) * 180.0f / PI_F;
        outer_deg = atanf(WHEEL_BASE_MM / (radius_abs + half_front)) * 180.0f / PI_F;
    }
    else
    {
        /* 半径比半个前轮距还小，几何上不成立，给 0 保护一下 */
        inner_deg = 0.0f;
        outer_deg = 0.0f;
    }

    /* 左转时左轮是内侧，右转时右轮是内侧；右转时角度取负 */
    if (delta_deg > 0.0f)
    {
        out->front_deg[0] = inner_deg;     /* 左前轮 = 内轮 */
        out->front_deg[1] = outer_deg;     /* 右前轮 = 外轮 */
    }
    else
    {
        out->front_deg[0] = -outer_deg;    /* 左前轮 = 外轮 */
        out->front_deg[1] = -inner_deg;    /* 右前轮 = 内轮 */
    }

    /* ======================================================================
     *  第 6 步：算左右后轮的差速比例（★这才真正控制电机★）
     * ----------------------------------------------------------------------
     *      内侧轮比例 = (R - 半个【后】轮距) / R    <- 比 1 小，转得慢
     *      外侧轮比例 = (R + 半个【后】轮距) / R    <- 比 1 大，转得快
     *
     *  ★ 为什么用后轮距 332，不用前轮距 342？
     *    因为差速是给两个【后】轮算的，
     *    走不同圆弧的是后轮，所以用后轮之间的距离。
     *
     *  哪个是内侧？
     *      向左转（R > 0）：左边是内侧 -> 左后轮慢
     *      向右转（R < 0）：右边是内侧 -> 右后轮慢
     *  下面的公式不用 if 判断，因为它自动就对：
     *
     *      左转 R = +557：
     *          左 = (557 - 166) / 557 = 0.70   <- 慢 ✓
     *          右 = (557 + 166) / 557 = 1.30   <- 快 ✓
     *
     *      右转 R = -557：
     *          左 = (-557 - 166) / -557 = 1.30 <- 快 ✓（左轮变成外侧了）
     *          右 = (-557 + 166) / -557 = 0.70 <- 慢 ✓
     * ==================================================================== */
    half_rear = WHEEL_TRACK_REAR_MM / 2.0f;       /* 332 / 2 = 166mm */

    ratio_left  = (radius - half_rear) / radius;
    ratio_right = (radius + half_rear) / radius;

    /* ----------------------------------------------------------------------
     *  差速强度微调（补偿欠阿克曼）
     * ----------------------------------------------------------------------
     *  实测转向梯形是"欠阿克曼"：内轮 35° / 外轮 25°，只差 10°，
     *  而理想阿克曼要求差 20°。后果是推头 —— 车实际转弯半径比前轮指向的大。
     *
     *  这里把"偏离 1 的部分"乘一个可调系数，相当于让后轴多转一点，
     *  用后轮差速把推头补回来：
     *      新比例 = 1 + (原比例 - 1) × ACKERMANN_GAIN
     *
     *  直行时比例恒为 1 -> (1-1)×GAIN = 0 -> 仍然是 1，不受影响。
     *  参数含义和调法见 config.h 里 ACKERMANN_GAIN 的说明。 */
    ratio_left  = 1.0f + (ratio_left  - 1.0f) * ACKERMANN_GAIN;
    ratio_right = 1.0f + (ratio_right - 1.0f) * ACKERMANN_GAIN;

    /* 防呆：GAIN 调得太大时，内侧比例可能被推到 0 甚至负数
     * （负数意味着该轮要倒转，那是不对的）。
     * 这里给一个下限，保证永远是正转。 */
    if (ratio_left < 0.05f)
    {
        ratio_left = 0.05f;
    }
    if (ratio_right < 0.05f)
    {
        ratio_right = 0.05f;
    }

    /* 比例 × 基准速度 = 每个后轮的目标转速 */
    out->rear_rpm[0] = base_rpm * ratio_left;
    out->rear_rpm[1] = base_rpm * ratio_right;

    /* ======================================================================
     *  第 7 步：转速限幅
     * ----------------------------------------------------------------------
     *  转弯的时候外侧轮会被乘上 1.30，
     *  如果 base_rpm 本来就接近上限，乘完就超了。
     *
     *  超了会怎样？
     *    速度环会一直顶在最大电流去追一个追不到的目标，
     *    电机发热、电流拉满、还可能触发保护。
     *
     *  怎么限？
     *    ★ 不能单独把超了的那个压到上限，
     *      那样左右比例就变了，车会走歪。
     *    ★ 要"两个一起等比缩小"，
     *      这样左右比例保持不变，车还是走对的圆弧。
     * ==================================================================== */

    /* 先找出两个里面绝对值大的那个 */
    rpm_max = fabsf(out->rear_rpm[0]);
    if (fabsf(out->rear_rpm[1]) > rpm_max)
    {
        rpm_max = fabsf(out->rear_rpm[1]);
    }

    /* 如果超过电机能力，就一起缩小 */
    if (rpm_max > DRIVE_RPM_MAX)
    {
        scale = DRIVE_RPM_MAX / rpm_max;
        out->rear_rpm[0] = out->rear_rpm[0] * scale;
        out->rear_rpm[1] = out->rear_rpm[1] * scale;
    }

    /* 到这里就全部算完了。
     * 上层（task_chassis.c）会把：
     *     out.rear_rpm[0] -> 左后轮电机的目标 rpm
     *     out.rear_rpm[1] -> 右后轮电机的目标 rpm
     *     out.rack_mm     -> 转向电机的目标位置
     * 而 front_deg[] 只留给调试看，不发给任何电机。 */
}
